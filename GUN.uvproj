# Keil uVision project GUN.uvproj, settings and files
target Target 1 (MCS-51)
  device: MC96FD316 ABOV Semiconductor
  cpu: IRAM(0x00 - 0xFF)  IROM(0-0x3FFF) CLOCK(12000000) MOD517DP
  output: FLOW-GUN-V16 +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: xxxUART_TX_INT   DEBUG_KNOCK
  c include: .\inc
  group src
    ./src/: drv_battery.c drv_led.c drv_motor.c main.c startup.a51 drv_uart.c sys_message.c sys_manage.c drv_key.c ble_comm.c drv_timer.c utiles.c drv_adc.c drv_charge.c
  group inc
    ./inc/: compiler.h drv_battery.h drv_key.h drv_led.h func_def.h drv_motor.h MC96FD316.h types.h drv_uart.h sys_message.h sys_manage.h ble_comm.h drv_charge.h
